## layers/meta-my-layer/conf/distro/my-distro.conf
```bitbake
require conf/distro/poky.conf

DISTRO = "my-distro"
DISTRO_NAME = "My experimental distro"
DISTRO_VERSION = "1.0"
```
